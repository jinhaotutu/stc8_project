# Keil uVision project demo.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC8H1K28 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x6FF8) CLOCK(35000000) MODP2
  output: demo +hex
  c flags: Optimize=8 SizeSpeed=1
  c define: USE_STC8A
  c include: ..\user;..\..\..\driver\433_ev1527;..\..\..\driver\button;..\..\..\driver\light;..\..\..\driver\soft_timer;..\..\..\fwlib\adc;..\..\..\fwlib\e2prom;..\..\..\fwlib\gpio;..\..\..\fwlib\hw_timer;..\..\..\fwlib\pwm;..\..\..\fwlib\uart;..\..\..\module\protocol;..\..\..\system;..\..\..\thirdlib\EasyLogger\easylogger\inc;..\..\..\fwlib\rcc;..\..\..\fwlib;..\..\..\fwlib\sleep
  group startup
    ./: STARTUP.A51
  group user
    ../user/: user_main.c
  group fwlib
    ../../../fwlib/e2prom/: e2prom.c
    ../../../fwlib/gpio/: gpio.c
    ../../../fwlib/hw_timer/: hw_timer.c
    ../../../fwlib/pwm/: pwm.c
    ../../../fwlib/uart/: uart.c
    ../../../fwlib/rcc/: rcc.c
    ../../../fwlib/adc/: adc.c
    ../../../fwlib/sleep/: sleep.c
  group driver
    ../../../driver/433_ev1527/: ev1527.c
    ../../../driver/soft_timer/: soft_timer.c
    ../../../driver/button/: button.c
  group module
    ../../../module/protocol/: protocol.c
  group system
    ../../../system/: main.c
